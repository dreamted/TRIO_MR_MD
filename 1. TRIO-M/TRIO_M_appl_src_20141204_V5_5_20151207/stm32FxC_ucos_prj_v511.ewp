# IAR project stm32FxC_ucos_prj_v511.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: include; lib_stm32\inc; lib_stm32\src; uC-CPU; uC-LIB; uCOS-II\Ports; uCOS-II\Source; uC-Probe
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: stm32FxC_ucos_prj_v511.srec
  ILINK.IlinkOutputFile: stm32FxC_ucos_prj_v511.out
  ILINK.IlinkIcfFile: init\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _MIMO_Type; __2rd; __PLLEnToggle
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Download\[bin]TRIO.BIN
  group dev
    dev/adf411x/: adf411x.c
    dev/bellwave/: bell860s_v0112.c
    dev/eeprom/: eep_24c64_v1104.c
    dev/extint/: extint_v0903.c extInt_vect_v0903.c
    dev/mem/: fsmc_sram.c
    dev/iobus/: PCA9555.c
  group lib
    init/: stm32f10x_flash.icf
    ./: stm32FxC_cpulib_gsi_20100114.a stm32FxC_lib_gsi_20100114.a
  group source
    code/: adcFunc.c Alarm.c ALC.C btest.c cdma.c DDR_WRCS.c de_protocol.c DE_Table.C exlib.c expio.c main.c swab.c
  group uc/os/port
    uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uc/os/source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uc/os/uc/cpu
    uC-CPU/: cpu.h cpu_a.asm
  group uc/os/uc/lib
    uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
