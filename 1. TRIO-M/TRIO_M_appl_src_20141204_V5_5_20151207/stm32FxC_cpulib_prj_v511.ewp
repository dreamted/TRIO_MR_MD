# IAR project stm32FxC_cpulib_prj_v511.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: include; lib_stm32\inc; lib_stm32\src; uC-CPU; uC-LIB; uCOS-II\Ports; uCOS-II\Source; uC-Probe
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: stm32FxC_cpulib_prj_v511.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  group (top)
    lib_stm32/src/: cortexm3_macro_v5.s stm32f10x_adc_0903.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac_v0902.c stm32f10x_dma.c stm32f10x_exti_v0903.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_main.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1_v0901.c stm32f10x_usart.c stm32f10x_wwdg.c
