# IAR project stm32FxC_lib_prj_v511.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: stm32FxC_lib_prj_v511.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: include; lib_stm32\inc; lib_stm32\src; uC-CPU; uC-LIB; uCOS-II\Ports; uCOS-II\Source; uC-Probe
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: stm32FxC_lib_prj_v511.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    lib/Vfd/: clcdlib_v0.1.c
    lib/at24c64/: eep_24c64_v0.1.c
    lib/ext/: extdevlib.c
    lib/keybuzz/: Keybuz5key_v0901.c
    lib/16c550/: serial6.c
    lib/timer/: timer_v0.1.c
    lib/uart1/: usart1_v0.1.c
    lib/uart2/: usart2_v0903.c
    lib/uart3/: usart3_v0.1.c
    lib/uart4/: usart4_v0.1.c
    lib/uart5/: usart5_v0.1.c
