# IAR project Backup (2) of stm32FxC_lib_prj_v511.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32FxC_lib_prj_v511.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: OS_INCLUDED; APPL_SRC
  ICCARM.CCIncludePath2: include; STM32F2xx_StdPeriph_Driver_v1212\; \STM32F2xx_StdPeriph_Driver_v1212\inc; uC-CPU; uC-LIB; uCOS-II\Ports; uCOS-II\Source; uC-Probe
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: stm32FxC_lib_prj_v511.srec
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    lib/at24c64/: lib_24c64_1208.c
    lib/ext/: lib_extdev_1208.c
    lib/fsmc/: lib_fsmc_sram_1208.c
    lib/timer/: lib_timer_1212.c
