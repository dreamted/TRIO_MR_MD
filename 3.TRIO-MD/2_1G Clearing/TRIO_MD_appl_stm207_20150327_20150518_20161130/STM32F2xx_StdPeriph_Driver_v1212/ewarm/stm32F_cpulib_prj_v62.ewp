# IAR project stm32F_cpulib_prj_v62.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32F_cpulib_prj_v62.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\uC-CPU; ..\..\uC-LIB; ..\..\uCOS-II\Ports; ..\..\uCOS-II\Source
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib_stm32
    ../src/: stm32f0xx_core.c stm32f0xx_macro.s stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash_1208.c stm32f2xx_fsmc.c stm32f2xx_gpio_1212.c stm32f2xx_iwdg.c stm32f2xx_main.c stm32f2xx_nvic_1208.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_usart.c stm32f2xx_usart1_1208.c stm32f2xx_usart2_1208.c stm32f2xx_usart3_1208.c stm32f2xx_usart4_1208.c stm32f2xx_usart5_1208.c stm32f2xx_usart6_1208.c stm32f2xx_usart7_1208.c
  group stm_core_m3
    ../: stm32f2xx_system.c
