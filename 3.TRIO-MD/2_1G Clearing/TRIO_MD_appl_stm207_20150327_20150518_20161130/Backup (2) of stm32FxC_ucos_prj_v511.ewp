# IAR project Backup (2) of stm32FxC_ucos_prj_v511.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32FxC_ucos_prj_v511.srec
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: include; STM32F2xx_StdPeriph_Driver_v1212\; STM32F2xx_StdPeriph_Driver_v1212\inc; uC-CPU; uC-LIB; uCOS-II\Ports; uCOS-II\Source; uC-Probe
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: download\[bin]TRIO.BIN
  ILINK.IlinkOutputFile: stm32FxC_ucos_prj_v511.out
  ILINK.IlinkIcfFile: init\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group []version
    ./: version.txt
  group dev
    dev/adf411x/: adf411x.c
    dev/bellwave/: bell860s_v0112.c
    dev/iobus/: PCA9555.c
  group source
    code/: aa_alc.c aa_expio.c aa_iAPD.c aa_protocol.c aa_serial1.c aa_Table.c aa_test.c adcFunc.c Alarm.c apl_dtu.c cdma.c exlib.c main.c swab.c
    dev/SFlash/: AT25DF641_v1204.c
  group u_interrupt/vector
    dev/intvect/: stm32f2xx_it_1208.c stm32f2xx_vector.c
  group u_lib
    init/: stm32f10x_flash.icf
    ./: stm32F_cpulib_prj_v62.a stm32F_devlib_prj_v62.a
  group uc/os/port
    uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uc/os/source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uc/os/uc/cpu
    uC-CPU/: cpu.h cpu_a.asm
  group uc/os/uc/lib
    uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
